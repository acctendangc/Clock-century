* NGSPICE file created from clock_century.ext - technology: sky130A

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for decode_day abstract view
.subckt decode_day VGND VPWR am_pm day_num[0] day_num[1] day_num[2] day_num[3] day_num[4]
+ hour_num[0] hour_num[1] hour_num[2] hour_num[3] hour_num[4] month[0] month[1] month[2]
+ month[3] year[0] year[1] year[2] year[3] year[4] year[5] year[6]
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for decode_all abstract view
.subckt decode_all VGND VPWR day[0] day[1] day[2] day[3] day[4] hour[0] hour[1] hour[2]
+ hour[3] hour[4] led_day[0] led_day[10] led_day[11] led_day[12] led_day[13] led_day[1]
+ led_day[2] led_day[3] led_day[4] led_day[5] led_day[6] led_day[7] led_day[8] led_day[9]
+ led_hour[0] led_hour[10] led_hour[11] led_hour[12] led_hour[13] led_hour[1] led_hour[2]
+ led_hour[3] led_hour[4] led_hour[5] led_hour[6] led_hour[7] led_hour[8] led_hour[9]
+ led_min[0] led_min[10] led_min[11] led_min[12] led_min[13] led_min[1] led_min[2]
+ led_min[3] led_min[4] led_min[5] led_min[6] led_min[7] led_min[8] led_min[9] led_month[0]
+ led_month[10] led_month[11] led_month[12] led_month[13] led_month[1] led_month[2]
+ led_month[3] led_month[4] led_month[5] led_month[6] led_month[7] led_month[8] led_month[9]
+ led_sec[0] led_sec[10] led_sec[11] led_sec[12] led_sec[13] led_sec[1] led_sec[2]
+ led_sec[3] led_sec[4] led_sec[5] led_sec[6] led_sec[7] led_sec[8] led_sec[9] led_year[0]
+ led_year[10] led_year[11] led_year[12] led_year[13] led_year[1] led_year[2] led_year[3]
+ led_year[4] led_year[5] led_year[6] led_year[7] led_year[8] led_year[9] minute[0]
+ minute[1] minute[2] minute[3] minute[4] minute[5] month[0] month[1] month[2] month[3]
+ second[0] second[1] second[2] second[3] second[4] second[5] year[0] year[1] year[2]
+ year[3] year[4] year[5] year[6]
.ends

* Black-box entry subcircuit for counter_all abstract view
.subckt counter_all VGND VPWR clk day[0] day[1] day[2] day[3] day[4] day_num[0] day_num[1]
+ day_num[2] day_num[3] day_num[4] dec[0] dec[1] dec[2] dec[3] dec[4] dec[5] done_dec[0]
+ done_dec[1] done_dec[2] done_dec[3] done_dec[4] done_inc[0] done_inc[1] done_inc[2]
+ done_inc[3] done_inc[4] en[0] en[1] en[2] en[3] en[4] en[5] hour[0] hour[1] hour[2]
+ hour[3] hour[4] hour_num[0] hour_num[1] hour_num[2] hour_num[3] hour_num[4] inc[0]
+ inc[1] inc[2] inc[3] inc[4] inc[5] minute[0] minute[1] minute[2] minute[3] minute[4]
+ minute[5] month[0] month[1] month[2] month[3] reset_n second[0] second[1] second[2]
+ second[3] second[4] second[5] year[0] year[1] year[2] year[3] year[4] year[5] year[6]
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for alarm abstract view
.subckt alarm VGND VPWR alarm_hour[0] alarm_hour[1] alarm_hour[2] alarm_hour[3] alarm_hour[4]
+ alarm_i alarm_min[0] alarm_min[1] alarm_min[2] alarm_min[3] alarm_min[4] alarm_min[5]
+ alarm_o clk hour[0] hour[1] hour[2] hour[3] hour[4] minute[0] minute[1] minute[2]
+ minute[3] minute[4] minute[5] rst_n
.ends

* Black-box entry subcircuit for decode_input abstract view
.subckt decode_input VGND VPWR button_dec button_inc dec[0] dec[1] dec[2] dec[3] dec[4]
+ dec[5] done_dec[0] done_dec[1] done_dec[2] done_dec[3] done_dec[4] done_inc[0] done_inc[1]
+ done_inc[2] done_inc[3] done_inc[4] en[0] en[1] en[2] en[3] en[4] en[5] inc[0] inc[1]
+ inc[2] inc[3] inc[4] inc[5] mode[0] mode[1] select[0] select[1] select[2] select[3]
+ select[4] select[5]
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

.subckt clock_century VGND VPWR alarm_hour[0] alarm_hour[1] alarm_hour[2] alarm_hour[3]
+ alarm_hour[4] alarm_i alarm_min[0] alarm_min[1] alarm_min[2] alarm_min[3] alarm_min[4]
+ alarm_min[5] alarm_o am_pm button_dec button_inc clk led_day[0] led_day[10] led_day[11]
+ led_day[12] led_day[13] led_day[1] led_day[2] led_day[3] led_day[4] led_day[5] led_day[6]
+ led_day[7] led_day[8] led_day[9] led_hour[0] led_hour[10] led_hour[11] led_hour[12]
+ led_hour[13] led_hour[1] led_hour[2] led_hour[3] led_hour[4] led_hour[5] led_hour[6]
+ led_hour[7] led_hour[8] led_hour[9] led_min[0] led_min[10] led_min[11] led_min[12]
+ led_min[13] led_min[1] led_min[2] led_min[3] led_min[4] led_min[5] led_min[6] led_min[7]
+ led_min[8] led_min[9] led_month[0] led_month[10] led_month[11] led_month[12] led_month[13]
+ led_month[1] led_month[2] led_month[3] led_month[4] led_month[5] led_month[6] led_month[7]
+ led_month[8] led_month[9] led_sec[0] led_sec[10] led_sec[11] led_sec[12] led_sec[13]
+ led_sec[1] led_sec[2] led_sec[3] led_sec[4] led_sec[5] led_sec[6] led_sec[7] led_sec[8]
+ led_sec[9] led_year[0] led_year[10] led_year[11] led_year[12] led_year[13] led_year[1]
+ led_year[2] led_year[3] led_year[4] led_year[5] led_year[6] led_year[7] led_year[8]
+ led_year[9] mode[0] mode[1] reset_n select[0] select[1] select[2] select[3] select[4]
+ select[5]
XFILLER_94_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_4_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output56_A net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_1_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_66_3_Left_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_3_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_3_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_2_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_3_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_2_Left_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_2_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_4_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_1_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_2_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_776 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_3_Left_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_3_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_decode_all_inst_hour[3] hour\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input18_A reset_n VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_80_3_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_2_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_82_2_Left_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput42 net42 VGND VGND VPWR VPWR led_hour[11] sky130_fd_sc_hd__buf_2
Xoutput31 net31 VGND VGND VPWR VPWR led_day[1] sky130_fd_sc_hd__buf_2
Xoutput53 net53 VGND VGND VPWR VPWR led_hour[9] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_25_2_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput64 net64 VGND VGND VPWR VPWR led_min[6] sky130_fd_sc_hd__buf_2
Xoutput75 net75 VGND VGND VPWR VPWR led_month[3] sky130_fd_sc_hd__buf_2
Xoutput97 net97 VGND VGND VPWR VPWR led_year[10] sky130_fd_sc_hd__buf_2
Xoutput86 net86 VGND VGND VPWR VPWR led_sec[13] sky130_fd_sc_hd__buf_2
XFILLER_88_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_1_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_37_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_62_1_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_4_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_3_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_4_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_2_Left_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_29_4_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_1_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_16_4_Left_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_2_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_1_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_4_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_4_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_3_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_2_Left_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_3_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_hour[2] hour\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output79_A net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_2_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_4_Left_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_counter_all_inst_day_num[4] day_num\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput43 net43 VGND VGND VPWR VPWR led_hour[12] sky130_fd_sc_hd__buf_2
Xoutput32 net32 VGND VGND VPWR VPWR led_day[2] sky130_fd_sc_hd__buf_2
Xoutput54 net54 VGND VGND VPWR VPWR led_min[0] sky130_fd_sc_hd__buf_2
Xoutput76 net76 VGND VGND VPWR VPWR led_month[4] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_25_2_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput65 net65 VGND VGND VPWR VPWR led_min[7] sky130_fd_sc_hd__buf_2
Xoutput98 net98 VGND VGND VPWR VPWR led_year[11] sky130_fd_sc_hd__buf_2
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput87 net87 VGND VGND VPWR VPWR led_sec[1] sky130_fd_sc_hd__buf_2
XFILLER_88_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_80_1_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_3_Left_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_2_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_3_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_month[10] net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_2_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_2_Left_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_4_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output61_A net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_minute[5] minute\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_2_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_3_Right_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_2_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_65_3_Left_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_70_3_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_2_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_10_1_Right_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_24_3_Right_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_4_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_2_Left_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_hour[1] hour\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_3_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_1_Right_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_3_Right_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_718 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_inc[5] inc\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_1_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_day_num[3] day_num\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput33 net33 VGND VGND VPWR VPWR led_day[3] sky130_fd_sc_hd__buf_2
Xoutput55 net55 VGND VGND VPWR VPWR led_min[10] sky130_fd_sc_hd__buf_2
Xoutput44 net44 VGND VGND VPWR VPWR led_hour[13] sky130_fd_sc_hd__buf_2
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput66 net66 VGND VGND VPWR VPWR led_min[8] sky130_fd_sc_hd__buf_2
Xoutput88 net88 VGND VGND VPWR VPWR led_sec[2] sky130_fd_sc_hd__buf_2
Xoutput99 net99 VGND VGND VPWR VPWR led_year[12] sky130_fd_sc_hd__buf_2
XFILLER_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput77 net77 VGND VGND VPWR VPWR led_month[5] sky130_fd_sc_hd__buf_2
XFILLER_88_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input23_A select[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_74_3_Left_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_1_Right_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_3_Right_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_2_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_2_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_3_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_2_Left_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_2_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_1_Right_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_19_4_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_27_3_Right_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_776 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_1_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_1_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_minute[4] minute\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_1_Right_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_3_Right_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_70_1_Right_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_2_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_2_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_15_1_Right_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_3_Right_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_1_Right_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_day_inst_month[3] month\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_2_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_4_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_1_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_4_Left_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_2_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_all_inst_hour[0] hour\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_16_1_Right_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_70_1_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_1_Right_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_inc[4] inc\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_day_num[2] day_num\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_51_3_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput34 net34 VGND VGND VPWR VPWR led_day[4] sky130_fd_sc_hd__buf_2
Xoutput56 net56 VGND VGND VPWR VPWR led_min[11] sky130_fd_sc_hd__buf_2
Xoutput67 net67 VGND VGND VPWR VPWR led_min[9] sky130_fd_sc_hd__buf_2
Xoutput45 net45 VGND VGND VPWR VPWR led_hour[1] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_9_1_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput78 net78 VGND VGND VPWR VPWR led_month[6] sky130_fd_sc_hd__buf_2
Xoutput89 net89 VGND VGND VPWR VPWR led_sec[3] sky130_fd_sc_hd__buf_2
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input16_A mode[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_1_Right_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_73_1_Right_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output84_A net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_2_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_2_Left_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input8_A alarm_min[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_3_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_1_Right_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_4_Left_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_3_Left_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_minute[3] minute\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_75_1_Right_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_done_inc[4] done_inc\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_3_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_4_Left_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_2_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_62_2_Left_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_76_1_Right_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_decode_day_inst_month[2] month\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload0 clknet_1_1__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__bufinv_16
XFILLER_94_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_3_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_3_Left_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_inc[3] inc\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_2_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_4_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_day_num[1] day_num\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput46 net46 VGND VGND VPWR VPWR led_hour[2] sky130_fd_sc_hd__buf_2
Xoutput57 net57 VGND VGND VPWR VPWR led_min[12] sky130_fd_sc_hd__buf_2
Xoutput35 net35 VGND VGND VPWR VPWR led_day[5] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR led_month[0] sky130_fd_sc_hd__buf_2
Xoutput79 net79 VGND VGND VPWR VPWR led_month[7] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_4_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_counter_all_inst_en[5] en\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_2_Left_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output77_A net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_2_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_3_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_3_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_2_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_2_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_826 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_2_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_3_Left_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_minute[2] minute\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_2_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_43_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_done_inc[3] done_inc\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_4_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_2_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_input_inst_done_inc[4] done_inc\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_1_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_day_inst_month[1] month\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_1_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_all_inst_led_year[6] net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_decode_day_inst_hour_num[4] hour_num\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_718 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_2_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_input_inst_inc[2] inc\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_4_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_counter_all_inst_day_num[0] day_num\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput25 net25 VGND VGND VPWR VPWR alarm_o sky130_fd_sc_hd__buf_2
Xoutput58 net58 VGND VGND VPWR VPWR led_min[13] sky130_fd_sc_hd__buf_2
Xoutput47 net47 VGND VGND VPWR VPWR led_hour[3] sky130_fd_sc_hd__buf_2
Xoutput36 net36 VGND VGND VPWR VPWR led_day[6] sky130_fd_sc_hd__buf_2
Xoutput69 net69 VGND VGND VPWR VPWR led_month[10] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_27_4_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_counter_all_inst_en[4] en\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_1_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_4_Left_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_2_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_minute[5] minute\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_3_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input21_A select[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_2_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_2_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_2_Left_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_4_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_minute[1] minute\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_done_inc[2] done_inc\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_1_Right_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_1_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_4_Left_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_2_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_input_inst_done_inc[3] done_inc\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_1_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_10_3_Right_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_3_Left_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_day_inst_month[0] month\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_decode_day_inst_hour_num[3] hour_num\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_3_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_91_1_Right_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xdecode_day_inst VGND VPWR net13 day_num\[0\] day_num\[1\] day_num\[2\] day_num\[3\]
+ day_num\[4\] hour_num\[0\] hour_num\[1\] hour_num\[2\] hour_num\[3\] hour_num\[4\]
+ month\[0\] month\[1\] month\[2\] month\[3\] year\[0\] year\[1\] year\[2\] year\[3\]
+ year\[4\] year\[5\] year\[6\] decode_day
XPHY_EDGE_ROW_11_3_Right_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_2_Left_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_1_Right_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_input_inst_inc[1] inc\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_12_3_Right_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput48 net48 VGND VGND VPWR VPWR led_hour[4] sky130_fd_sc_hd__buf_2
Xoutput26 net26 VGND VGND VPWR VPWR led_day[0] sky130_fd_sc_hd__buf_2
Xoutput37 net37 VGND VGND VPWR VPWR led_day[7] sky130_fd_sc_hd__buf_2
Xoutput59 net59 VGND VGND VPWR VPWR led_min[1] sky130_fd_sc_hd__buf_2
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_counter_all_inst_en[3] en\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_4_Left_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_2_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_93_1_Right_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_3_Left_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_minute[4] minute\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_3_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input14_A button_dec VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_2_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output82_A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_1_Right_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_clk_X clknet_1_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input6_A alarm_i VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_3_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_4_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_minute[0] minute\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_3_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_done_inc[1] done_inc\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_4_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_4_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_led_year[11] net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_91_2_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_2_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_input_inst_done_inc[2] done_inc\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_2_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_3_Left_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_year[4] net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_2_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_day_inst_hour_num[2] hour_num\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_2_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_4_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_1_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_inc[0] inc\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput49 net49 VGND VGND VPWR VPWR led_hour[5] sky130_fd_sc_hd__buf_2
Xoutput27 net27 VGND VGND VPWR VPWR led_day[10] sky130_fd_sc_hd__buf_2
Xoutput38 net38 VGND VGND VPWR VPWR led_day[8] sky130_fd_sc_hd__buf_2
XFILLER_1_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_en[2] en\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_3_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_2_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_3_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_en[5] en\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_decode_all_inst_minute[3] minute\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_1_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output75_A net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_4_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_1_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_4_Left_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_2_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_79_1_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_all_inst_day[4] day\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_done_inc[0] done_inc\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_2_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_4_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_4_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_year[10] net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_2_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_input_inst_done_inc[1] done_inc\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output38_A net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_alarm_inst_rst_n net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_718 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_51_2_Left_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_day_inst_hour_num[1] hour_num\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_2_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_3_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_2_Right_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_1_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_4_Left_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_3_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_776 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_2_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_53_3_Left_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_2_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput39 net39 VGND VGND VPWR VPWR led_day[9] sky130_fd_sc_hd__buf_2
Xoutput28 net28 VGND VGND VPWR VPWR led_day[11] sky130_fd_sc_hd__buf_2
XFILLER_88_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_69_3_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_en[1] en\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_776 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_1_Right_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_2_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_2_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_2_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_1_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_en[4] en\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_minute[2] minute\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_1_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_1_Right_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_2_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_4_Left_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_81_2_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_3_Left_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_day[3] day\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output106_A net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_22_1_Right_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_78_3_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_13_2_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_input_inst_done_inc[0] done_inc\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_3_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_23_1_Right_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_all_inst_led_year[2] net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_decode_day_inst_hour_num[0] hour_num\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_3_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_2_Right_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output50_A net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_1_Right_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_1_Right_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xdecode_all_inst VGND VPWR day\[0\] day\[1\] day\[2\] day\[3\] day\[4\] hour\[0\]
+ hour\[1\] hour\[2\] hour\[3\] hour\[4\] net26 net27 net28 net29 net30 net31 net32
+ net33 net34 net35 net36 net37 net38 net39 net40 net41 net42 net43 net44 net45 net46
+ net47 net48 net49 net50 net51 net52 net53 net54 net55 net56 net57 net58 net59 net60
+ net61 net62 net63 net64 net65 net66 net67 net68 net69 net70 net71 net72 net73 net74
+ net75 net76 net77 net78 net79 net80 net81 net82 net83 net84 net85 net86 net87 net88
+ net89 net90 net91 net92 net93 net94 net95 net96 net97 net98 net99 net100 net101
+ net102 net103 net104 net105 net106 net107 net108 net109 minute\[0\] minute\[1\]
+ minute\[2\] minute\[3\] minute\[4\] minute\[5\] month\[0\] month\[1\] month\[2\]
+ month\[3\] second\[0\] second\[1\] second\[2\] second\[3\] second\[4\] second\[5\]
+ year\[0\] year\[1\] year\[2\] year\[3\] year\[4\] year\[5\] year\[6\] decode_all
XPHY_EDGE_ROW_90_2_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_3_Left_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_2_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output98_A net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_2_Right_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_3_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_1_Right_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_2_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput29 net29 VGND VGND VPWR VPWR led_day[12] sky130_fd_sc_hd__buf_2
XFILLER_1_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_1_Right_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_en[0] en\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_4_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_2_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_2_Right_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_1_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_decode_input_inst_en[3] en\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_decode_all_inst_minute[1] minute\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_1_Right_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_82_1_Right_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_1_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_3_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_3_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_1_Right_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_1_Right_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_all_inst_day[2] day\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A alarm_min[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_4_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input4_A alarm_hour[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_2_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_4_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_1_Right_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_all_inst_led_sec[7] net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_1_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_4_Left_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_1_Right_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_3_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_2_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_86_1_Right_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_3_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_year[6] year\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_1_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_4_Left_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_decode_input_inst_en[2] en\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_minute[0] minute\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_3_Left_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_3_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_2_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_all_inst_day[1] day\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_3_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_2_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_4_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_4_Left_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_3_Left_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_2_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_3_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_77_3_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_3_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_2_Right_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_1_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_counter_all_inst_year[5] year\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_input_inst_en[1] en\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload0_A clknet_1_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_4_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_all_inst_day[0] day\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_1_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_2_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output66_A net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_3_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_output104_A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_reset_n net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xcounter_all_inst VGND VPWR clknet_1_0__leaf_clk day\[0\] day\[1\] day\[2\] day\[3\]
+ day\[4\] day_num\[0\] day_num\[1\] day_num\[2\] day_num\[3\] day_num\[4\] dec\[0\]
+ dec\[1\] dec\[2\] dec\[3\] dec\[4\] dec\[5\] done_dec\[0\] done_dec\[1\] done_dec\[2\]
+ done_dec\[3\] done_dec\[4\] done_inc\[0\] done_inc\[1\] done_inc\[2\] done_inc\[3\]
+ done_inc\[4\] en\[0\] en\[1\] en\[2\] en\[3\] en\[4\] en\[5\] hour\[0\] hour\[1\]
+ hour\[2\] hour\[3\] hour\[4\] hour_num\[0\] hour_num\[1\] hour_num\[2\] hour_num\[3\]
+ hour_num\[4\] inc\[0\] inc\[1\] inc\[2\] inc\[3\] inc\[4\] inc\[5\] minute\[0\]
+ minute\[1\] minute\[2\] minute\[3\] minute\[4\] minute\[5\] month\[0\] month\[1\]
+ month\[2\] month\[3\] net110 second\[0\] second\[1\] second\[2\] second\[3\] second\[4\]
+ second\[5\] year\[0\] year\[1\] year\[2\] year\[3\] year\[4\] year\[5\] year\[6\]
+ counter_all
XFILLER_93_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput1 alarm_hour[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
XFILLER_37_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_1_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_4_Left_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_4_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_3_Right_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_alarm_inst_minute[5] minute\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_4_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_year[4] year\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_3_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_3_Right_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_en[0] en\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_2_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_3_Right_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_4_Left_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_2_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_4_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_3_Left_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_3_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_3_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_67_3_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_A alarm_min[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_sec[4] net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_47_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_A alarm_hour[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 alarm_hour[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
XFILLER_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_counter_all_inst_hour_num[4] hour_num\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_2_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_input_inst_dec[5] dec\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_718 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_4_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output41_A net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_alarm_inst_minute[4] minute\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_4_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_76_3_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_counter_all_inst_year[3] year\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_output89_A net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_4_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_1_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_2_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_2_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_4_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_2_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_4_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_3_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_sec[3] net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_1_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_2_Right_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_1_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_90_2_Left_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput3 alarm_hour[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XFILLER_92_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_26_2_Right_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_hour_num[3] hour_num\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_2_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_dec[4] dec\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_month[3] month\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_alarm_inst_minute[3] minute\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_2_Right_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_80_2_Right_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_96_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_counter_all_inst_year[2] year\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_3_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_counter_all_inst_inc[5] inc\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_10_4_Left_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_2_Right_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_2_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_1_Right_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_4_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_3_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_29_2_Right_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_counter_all_inst_done_dec[4] done_dec\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_31_1_Right_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output64_A net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_1_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_1_Right_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output102_A net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 alarm_hour[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
XFILLER_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_3_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_counter_all_inst_hour_num[2] hour_num\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_dec[3] dec\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_month[2] month\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_alarm_inst_minute[2] minute\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_year[1] year\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_inc[4] inc\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_2_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_day[4] day\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_89_2_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_1_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_826 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_3_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_2_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_75_3_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_done_dec[3] done_dec\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_3_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_2_Left_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_done_dec[4] done_dec\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_3_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_sec[1] net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output57_A net57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_2_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_47_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_718 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_2_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput5 alarm_hour[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
XFILLER_49_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_hour_num[1] hour_num\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_dec[2] dec\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_month[1] month\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_day_inst_year[6] year\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_alarm_inst_minute[1] minute\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_year[0] year\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_inc[3] inc\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_3_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_day[3] day\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_1_Right_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_776 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input19_A select[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_decode_all_inst_led_month[7] net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_1_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output87_A net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_1_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_1_Right_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_done_dec[2] done_dec\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_29_1_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_2_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_707 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_done_dec[3] done_dec\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_68_1_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_3_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_59_1_Right_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_sec[0] net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_3_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_3_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_3_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_2_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_1_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_4_Left_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_4_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput6 alarm_i VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XFILLER_49_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_hour_num[0] hour_num\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_input_inst_dec[1] dec\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_2_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_4_Left_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_2_Right_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_all_inst_month[0] month\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_2_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_day_inst_year[5] year\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_alarm_inst_minute[0] minute\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_3_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_3_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_counter_all_inst_inc[2] inc\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_92_2_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_3_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_2_Right_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output32_A net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_day[2] day\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput20 select[1] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_99_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_2_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_2_Left_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_2_Right_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_2_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_done_dec[1] done_dec\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_2_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_88_2_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_18_2_Right_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_done_dec[2] done_dec\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_3_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_3_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_3_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_2_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_decode_all_inst_led_min[12] net57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_2_Right_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_4_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output62_A net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 alarm_min[0] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_49_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_dec[0] dec\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_1_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_4_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_2_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_2_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_day_inst_year[4] year\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_counter_all_inst_inc[1] inc\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_1_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_day[1] day\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_2_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput21 select[2] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput10 alarm_min[3] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_99_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_1_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_4_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_month[5] net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_30_3_Right_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_1_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_done_dec[0] done_dec\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_2_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_3_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input24_A select[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_3_Right_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_all_inst_led_hour[6] net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_input_inst_done_dec[1] done_dec\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_2_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_3_Right_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_all_inst_led_min[11] net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_2_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_4_Left_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_2_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_2_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output55_A net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput8 alarm_min[1] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XFILLER_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_1_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_4_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_3_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_754 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_day_inst_year[3] year\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_3_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_7_4_Left_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_year[6] year\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_counter_all_inst_inc[0] inc\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_2_Left_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_2_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_counter_all_inst_day[0] day\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput22 select[3] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
Xinput11 alarm_min[4] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_99_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_97_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_4_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_second[5] second\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_4_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_2_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_0__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_3_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_3_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_2_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_1_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input17_A mode[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_input_inst_done_dec[0] done_dec\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_2_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_2_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input9_A alarm_min[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_3_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_1_Right_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_all_inst_led_min[10] net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_87_2_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_2_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output48_A net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 alarm_min[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_18_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_27_3_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_73_3_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_1_Right_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_2_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_2_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_day_inst_year[2] year\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_3_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_89_2_Left_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_year[5] year\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput12 alarm_min[5] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
Xinput23 select[4] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_7_2_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_led_month[3] net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_second[4] second\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output30_A net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_80_3_Left_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_all_inst_led_day[8] net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_2_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_4_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_2_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_hour[4] net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_2_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_led_min[9] net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_2_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_78_1_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_3_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_2_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_4_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_2_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_decode_day_inst_year[1] year\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output60_A net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput100 net100 VGND VGND VPWR VPWR led_year[13] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_year[4] year\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_1_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput13 am_pm VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
Xinput24 select[5] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_3_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_counter_all_inst_second[3] second\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_day[7] net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_2_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_min[8] net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_2_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input22_A select[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_3_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output90_A net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_3_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_2_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_2_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_2_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_776 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_79_2_Left_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xalarm_inst VGND VPWR net1 net2 net3 net4 net5 net6 net7 net8 net9 net10 net11 net12
+ net25 clknet_1_1__leaf_clk hour\[0\] hour\[1\] hour\[2\] hour\[3\] hour\[4\] minute\[0\]
+ minute\[1\] minute\[2\] minute\[3\] minute\[4\] minute\[5\] net110 alarm
XFILLER_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_4_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_3_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_day_inst_year[0] year\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_3_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_86_2_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput101 net101 VGND VGND VPWR VPWR led_year[1] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_7_3_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_year[3] year\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_2_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_3_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_3_Left_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_3_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput14 button_dec VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
XFILLER_69_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_2_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_second[2] second\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_88_2_Left_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_4_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_hour[2] net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_1_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_1_Right_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_min[7] net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_3_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A button_inc VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_2_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_2_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_68_1_Right_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input7_A alarm_min[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_3_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_2_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_1_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_4_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_69_1_Right_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_1_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output46_A net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_second[5] second\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput102 net102 VGND VGND VPWR VPWR led_year[2] sky130_fd_sc_hd__buf_2
XFILLER_87_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_4_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_year[2] year\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput15 button_inc VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_2_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_3_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_second[1] second\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_decode_all_inst_led_day[5] net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_4_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_all_inst_led_hour[10] net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_3_Right_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_86_1_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_3_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_3_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_1_Right_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_min[6] net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_3_Right_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_2_Left_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_2_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_3_Right_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_4_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_95_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_3_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_16_3_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_60_3_Left_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_41_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_50_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_all_inst_second[4] second\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput103 net103 VGND VGND VPWR VPWR led_year[3] sky130_fd_sc_hd__buf_2
XFILLER_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_2_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_year[1] year\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_month[3] month\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_2_Left_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput16 mode[0] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_2_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_counter_all_inst_second[0] second\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_58_1_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_2_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_2_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_3_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_led_hour[0] net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_2_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_3_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_all_inst_led_min[5] net63 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_2_Left_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_97_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_4_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output69_A net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_1_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_2_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_4_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input20_A select[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_3_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_4_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_3_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_second[3] second\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput104 net104 VGND VGND VPWR VPWR led_year[4] sky130_fd_sc_hd__buf_2
XFILLER_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_dec[5] dec\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_decode_all_inst_year[0] year\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_month[2] month\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_4_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput17 mode[1] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_2_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_76_1_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_2_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_4_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_8_4_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_2_Left_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_3_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_all_inst_led_min[4] net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_1_Right_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_2_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_4_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_89_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_2_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_1_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_2_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_2_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_1_Right_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_2_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_4_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A am_pm VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_counter_all_inst_hour[4] hour\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_4_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_2_Left_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input5_A alarm_hour[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_1_Right_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_second[2] second\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_1_Right_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput105 net105 VGND VGND VPWR VPWR led_year[5] sky130_fd_sc_hd__buf_2
XFILLER_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_dec[4] dec\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_counter_all_inst_month[1] month\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput18 reset_n VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_94_1_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_3_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_2_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_1_Right_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_day[2] net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_10_2_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_4_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_day_inst_day_num[4] day_num\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_2_Left_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_1_Right_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_2_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_3_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_min[3] net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_1_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_2_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_2_Right_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_1_Right_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_3_Left_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_24_3_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_2_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_2_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_2_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_62_2_Right_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_1_Right_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_718 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_hour[3] hour\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_3_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_86_2_Left_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_13_4_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_3_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_10_2_Right_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_2_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_63_2_Right_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_1_Right_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_all_inst_second[1] second\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_66_1_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput106 net106 VGND VGND VPWR VPWR led_year[6] sky130_fd_sc_hd__buf_2
XFILLER_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_alarm_inst_hour[4] hour\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_counter_all_inst_dec[3] dec\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_month[0] month\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_2_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput19 select[0] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_2_Right_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_2_Right_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output37_A net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_day_inst_day_num[3] day_num\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_12_2_Right_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_2_Right_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_4_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_3_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_1_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_all_inst_led_min[2] net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_2_Right_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_2_Right_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_4_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_2_Left_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_2_Right_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_67_2_Right_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_2_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_hour[2] hour\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_3_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output67_A net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_4_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_68_2_Right_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_1_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_2_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_second[0] second\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_3_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput107 net107 VGND VGND VPWR VPWR led_year[7] sky130_fd_sc_hd__buf_2
XFILLER_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_alarm_inst_hour[3] hour\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_dec[2] dec\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_2_Right_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_2_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_67_2_Left_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_18_1_Right_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_decode_all_inst_led_day[0] net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_day_inst_day_num[2] day_num\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_3_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_93_1_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_1_Right_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_69_3_Left_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_3_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output97_A net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_2_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_2_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_76_2_Left_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_2_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_2_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_1_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_counter_all_inst_hour[1] hour\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_2_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_1_Right_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_78_3_Left_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_3_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_2_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_3_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input11_A alarm_min[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput108 net108 VGND VGND VPWR VPWR led_year[8] sky130_fd_sc_hd__buf_2
XFILLER_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_1_Right_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput90 net90 VGND VGND VPWR VPWR led_sec[4] sky130_fd_sc_hd__buf_2
XANTENNA_alarm_inst_hour[2] hour\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_2_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_counter_all_inst_dec[1] dec\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input3_A alarm_hour[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_2_Left_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_826 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_4_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_1_Right_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_1_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_decode_day_inst_day_num[1] day_num\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_2_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_3_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_3_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_4_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_94_2_Left_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_4_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_4_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_1_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_1_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_2_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_718 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_74_1_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_counter_all_inst_hour[0] hour\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_2_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xdecode_input_inst VGND VPWR net14 net15 dec\[0\] dec\[1\] dec\[2\] dec\[3\] dec\[4\]
+ dec\[5\] done_dec\[0\] done_dec\[1\] done_dec\[2\] done_dec\[3\] done_dec\[4\] done_inc\[0\]
+ done_inc\[1\] done_inc\[2\] done_inc\[3\] done_inc\[4\] en\[0\] en\[1\] en\[2\]
+ en\[3\] en\[4\] en\[5\] inc\[0\] inc\[1\] inc\[2\] inc\[3\] inc\[4\] inc\[5\] net16
+ net17 net19 net20 net21 net22 net23 net24 decode_input
XFILLER_36_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_2_Right_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_1_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_2_Left_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_2_Right_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net109 VGND VGND VPWR VPWR led_year[9] sky130_fd_sc_hd__buf_2
XFILLER_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput91 net91 VGND VGND VPWR VPWR led_sec[5] sky130_fd_sc_hd__buf_2
Xoutput80 net80 VGND VGND VPWR VPWR led_month[8] sky130_fd_sc_hd__buf_2
XANTENNA_alarm_inst_hour[1] hour\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_counter_all_inst_dec[0] dec\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_2_Right_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_2_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_776 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_4_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_802 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_4_Left_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_2_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_2_Right_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_83_1_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_2_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_2_Right_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_3_Left_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_alarm_inst_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_day_inst_day_num[0] day_num\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output35_A net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_2_Right_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_2_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_54_2_Right_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_2_Left_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_4_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_55_2_Right_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_44_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_1_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_68_3_Left_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_13_3_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_2_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_2_Right_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_1_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_2_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_75_2_Left_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_3_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_2_Right_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput70 net70 VGND VGND VPWR VPWR led_month[11] sky130_fd_sc_hd__buf_2
XFILLER_96_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput81 net81 VGND VGND VPWR VPWR led_month[9] sky130_fd_sc_hd__buf_2
XANTENNA_alarm_inst_hour[0] hour\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output65_A net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput92 net92 VGND VGND VPWR VPWR led_sec[6] sky130_fd_sc_hd__buf_2
XFILLER_49_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_4_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_1_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_2_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_3_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_2_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_13_3_Right_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_3_Left_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_2_Right_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_3_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_2_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_2_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_2_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output28_A net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_14_3_Right_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_59_2_Right_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_84_2_Left_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_2_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_4_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_1_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_1__f_clk_X clknet_1_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_1_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_15_3_Right_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_decode_all_inst_led_day[13] net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_3_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_3_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_3_Right_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_2_Left_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_4_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_3_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_27_1_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_2_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_3_Right_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_4_Left_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput60 net60 VGND VGND VPWR VPWR led_min[2] sky130_fd_sc_hd__buf_2
XFILLER_96_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput82 net82 VGND VGND VPWR VPWR led_sec[0] sky130_fd_sc_hd__buf_2
Xoutput71 net71 VGND VGND VPWR VPWR led_month[12] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR led_sec[7] sky130_fd_sc_hd__buf_2
XFILLER_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_1_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_4_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_2_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_2_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_3_Right_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_1_Right_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_2_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_2_Left_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input1_A alarm_hour[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_3_Right_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_1_Right_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_2_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_4_Left_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_3_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_1_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output40_A net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_1_Right_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_3_Left_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_1_Right_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_65_2_Left_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_2_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_2_Right_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_1_Right_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_decode_all_inst_led_sec[11] net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_91_1_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_3_Left_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput61 net61 VGND VGND VPWR VPWR led_min[3] sky130_fd_sc_hd__buf_2
Xoutput50 net50 VGND VGND VPWR VPWR led_hour[6] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_12_3_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput83 net83 VGND VGND VPWR VPWR led_sec[10] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR led_sec[8] sky130_fd_sc_hd__buf_2
Xoutput72 net72 VGND VGND VPWR VPWR led_month[13] sky130_fd_sc_hd__buf_2
XFILLER_1_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_72_2_Right_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_1_Right_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_72_3_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_2_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_74_2_Left_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_2_Right_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_3_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_2_Right_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_1_Right_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_2_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_1_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_2_Right_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_74_2_Right_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_3_Left_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_3_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_decode_all_inst_led_day[11] net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_2_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_2_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_2_Right_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_2_Right_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_2_Left_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_2_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_4_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire110_X net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_40_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_17_1_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_4_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_2_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_63_1_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_2_Right_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_2_Right_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_94_2_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_3_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_2_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput40 net40 VGND VGND VPWR VPWR led_hour[0] sky130_fd_sc_hd__buf_2
Xoutput51 net51 VGND VGND VPWR VPWR led_hour[7] sky130_fd_sc_hd__buf_2
Xoutput84 net84 VGND VGND VPWR VPWR led_sec[11] sky130_fd_sc_hd__buf_2
Xoutput62 net62 VGND VGND VPWR VPWR led_min[4] sky130_fd_sc_hd__buf_2
Xoutput73 net73 VGND VGND VPWR VPWR led_month[1] sky130_fd_sc_hd__buf_2
XANTENNA_counter_all_inst_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput95 net95 VGND VGND VPWR VPWR led_sec[9] sky130_fd_sc_hd__buf_2
XFILLER_48_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_2_Right_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_2_Right_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_92_2_Left_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_2_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output63_A net63 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_1_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_78_2_Right_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_17_4_Left_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_1_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_2_Right_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_2_Left_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output26_A net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_1_Right_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_2_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_2_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_2_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire110 net18 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_4
XFILLER_7_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_3_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_4_Left_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_1_Right_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_81_1_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_3_Left_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_2_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_decode_all_inst_hour[4] hour\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_3_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output93_A net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_3_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_756 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_3_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_2_Left_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput41 net41 VGND VGND VPWR VPWR led_hour[10] sky130_fd_sc_hd__buf_2
Xoutput52 net52 VGND VGND VPWR VPWR led_hour[8] sky130_fd_sc_hd__buf_2
Xoutput30 net30 VGND VGND VPWR VPWR led_day[13] sky130_fd_sc_hd__buf_2
Xoutput85 net85 VGND VGND VPWR VPWR led_sec[12] sky130_fd_sc_hd__buf_2
Xoutput63 net63 VGND VGND VPWR VPWR led_min[5] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR led_month[2] sky130_fd_sc_hd__buf_2
XFILLER_1_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput96 net96 VGND VGND VPWR VPWR led_year[0] sky130_fd_sc_hd__buf_2
XFILLER_1_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_2_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
.ends
